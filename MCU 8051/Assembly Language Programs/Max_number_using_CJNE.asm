ORG 0000H
MOV R0, #20H
MOV @R0, #43H ;1St
INC R0
MOV @R0, #68H ;2nd
INC R0
MOV @R0, #41H ;3rd
INC R0
MOV @R0, #3FH ;4th
INC R0
MOV @R0, #74H ;5th
INC R0
MOV @R0, #0F8H ;6th
INC R0
MOV @R0, #66H ;7th
INC R0
MOV @R0, #14H ;8th
INC R0
MOV @R0, #97H ;9th
INC R0
MOV @R0, #7FH ;10th

MOV R0, #20H
MOV R1, #09H
MOV A, @R0
NEXT: INC R0
MOV 02H, @R0
CJNE A, 02H, CHECK
CHECK: JNC DCR
MOV A, @R0
DCR: DJNZ R1, NEXT
MOV 30H, A
END

INC R0
