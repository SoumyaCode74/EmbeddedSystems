# Keil uVision project First1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT80C51RD2 Microchip
  cpu: IRAM(0x00 - 0xFF) XRAM(0x00 - 0x3FF) CLOCK(40000000) MODP2
  output: First1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: First1.asm Toggle_LEDs.asm
